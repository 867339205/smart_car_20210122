# Keil uVision project CESHI.uvprojx, settings and files
target ceshi (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.3.0
  cpu: IRAM(0x20000000,0x00005000) IROM(0x08000000,0x00010000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: CESHI +hex
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: STM32F10X_MD,USE_STDPERIPH_DRIVER
  c include: ..\CORE;..\LIB\inc;..\USER;..\DRIVES\motor;..\UCOSII\CONFIG;..\UCOSII\CORE;..\UCOSII\PORT;..\SYSTEM\delay;..\SYSTEM\system;..\SYSTEM\usart;..\DRIVES\avoid;..\DRIVES\infrared;..\DRIVES\rudder;..\DRIVES\wave
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group CORE
    ../CORE/: core_cm3.c startup_stm32f10x_md.s
  group LIB
    ../LIB/src/: misc.c stm32f10x_gpio.c stm32f10x_rcc.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_exti.c
  group SYSTEM
    ../SYSTEM/delay/: delay.c
    ../SYSTEM/system/: stm32f10x_it.c system_stm32f10x.c sys.c
    ../SYSTEM/usart/: usart.c
  group DRIVES
    ../DRIVES/motor/: motor.c
    ../DRIVES/avoid/: avoid.c
    ../DRIVES/rudder/: rudder.c
    ../DRIVES/wave/: wave.c
    ../DRIVES/infrared/: infrared.c
  group USER
    ./: main.c
  group UCOSII-CORE
    ../UCOSII/CORE/: os_core.c os_flag.c os_mbox.c os_mem.c os_mutex.c os_q.c os_sem.c os_task.c os_time.c os_tmr.c
  group UCOSII-PORT
    ../UCOSII/PORT/: os_cpu.h os_cpu_a.asm os_cpu_c.c
  group UCOSII-CONFIG
    ../UCOSII/CONFIG/: os_cfg.h includes.h
